<?xml version="1.0" encoding="utf-8"?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_optx.xsd">
	<SchemaVersion>1.0</SchemaVersion>
	<Target>
		<TargetName>New_quadrotor_basic</TargetName>
		<ToolsetNumber>0x4</ToolsetNumber>
		<ToolsetName>ARM-ADS</ToolsetName>
		<TargetOption>
			
			<DebugOpt>
				<uSim>0</uSim>
				<uTrg>1</uTrg>
				<nTsel>11</nTsel>
				<pMon>STLink\ST-LINKIII-KEIL_SWO.dll</pMon>
				
			</DebugOpt>
			<TargetDriverDllRegistry>
				<SetRegEntry>
					<Number>0</Number>
					<Key>ST-LINKIII-KEIL_SWO</Key>
					<Name>UL2CM3(-S0 -C0 -P0 -FD20000000 -FC1000 -FN1 -FF0stm32l4xx_256 -FS08000000 -FL040000 -FP0($$Device:STM32L432KCUx$CMSIS/Flash/STM32L4xx_256.FLM))</Name>
				</SetRegEntry>
			</TargetDriverDllRegistry>
		</TargetOption>
	</Target>
</ProjectOpt>